Commit message: all

File: ros_sim/urdf/diff.urdf (robot description, URDF)
Before this commit: robot differential_drive, 3 links, 2 joints
Links:
- link base_link: geometry visual sphere radius=0.05
